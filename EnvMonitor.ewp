# IAR project EnvMonitor.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: D:\outsource\EnvMonitor\common; D:\outsource\EnvMonitor\os\include; D:\outsource\EnvMonitor\platform\stm32f10x\inc; D:\outsource\EnvMonitor\os\portable\cm3; D:\outsource\EnvMonitor\board; D:\outsource\EnvMonitor\platform\cm3; D:\outsource\EnvMonitor\board\sensor; D:\outsource\EnvMonitor\gui\inc; D:\outsource\EnvMonitor\gui; D:\outsource\EnvMonitor\gui\demo; D:\outsource\EnvMonitor\board\ui
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EnvMonitor.hex
  ILINK.IlinkOutputFile: EnvMonitor.out
  ILINK.IlinkAdditionalLibs: D:\outsource\EnvMonitor\gui\STemWin532_CM3_OS_IAR.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: D:\outsource\EnvMonitor\board\sensor; D:\outsource\EnvMonitor\board; D:\outsource\EnvMonitor\common; D:\outsource\EnvMonitor\os\include; D:\outsource\EnvMonitor\os\portable; D:\outsource\EnvMonitor\os\portable\cm3; D:\outsource\EnvMonitor\os; D:\outsource\EnvMonitor\platform\cm3; D:\outsource\EnvMonitor\platform\stm32f10x\inc
  ICCARM.CCOptLevel: 3
  group board
    board/: application.c application.h board.c board.h display.c display.h FreeRTOSConfig.h global.h i2c.c i2c.h main.c pinconfig.c pinconfig.h serial.c serial.h stm32f10x_cfg.h stm32f10x_it.c stm32f10x_vector.c tft.c tft.h
    board/sensor/: environment.h
  group board/sensor
    board/sensor/: am2302.c am2302.h bh1750.c bh1750.h bmp280.c bmp280.h gp2y1050.c gp2y1050.h pms5003s.c pms5003s.h sound.c sound.h voc.c voc.h
  group board/ui
    board/ui/: background.c background.h
  group common
    common/: assert.h sysdef.h trace.h
  group gui
    gui/: GUI_X_OS.c GUIConf.c GUIConf.h LCDConf_FlexColor_Template.c LCDConf_FlexColor_Template.h
  group gui/inc
    gui/inc/: BUTTON.h BUTTON_Private.h CALENDAR.h CHECKBOX.h CHECKBOX_Private.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h Global.h GRAPH.h GRAPH_Private.h GUI.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_SIM_Win32.h GUI_SPRITE_Private.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_DCache.h GUIDRV_DCache_Private.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_FlexColor_Private.h GUIDRV_Lin.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Opt_8.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h GUIMTDRV_TangoC32.h GUITDRV_ADS7846.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h IMAGE.h IMAGE_Private.h KNOB.h KNOB_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SLIDER.h SLIDER_Private.h SPINBOX.h SPINBOX_Private.h SWIPELIST.h SWIPELIST_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h
  group os
    os/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group os/include
    os/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group os/portable/cm3
    os/portable/cm3/: heap_2.c port.c port.h portasm.s portmacro.h
  group platform/cm3
    platform/cm3/: cm3_core.h cm3_core.s
  group platform/stm32f10x/inc
    platform/stm32f10x/inc/: stm32f10x_adc.h stm32f10x_crc.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_it.h stm32f10x_iwdg.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_rcc.h stm32f10x_scb.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_usart.h stm32f10x_wwdg.h
  group platform/stm32f10x/src
    platform/stm32f10x/src/: stm32f10x_adc.c stm32f10x_crc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_scb.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_usart.c stm32f10x_wwdg.c
